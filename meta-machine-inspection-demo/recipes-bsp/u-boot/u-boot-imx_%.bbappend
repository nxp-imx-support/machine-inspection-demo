FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_real-time-edge += "file://0001-Use-Basler-device-tree-for-Linux.patch"

